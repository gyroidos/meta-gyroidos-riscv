KERNEL_IMAGE_FILE = "cml-kernel/Image-initramfs-${MACHINE}.bin"
OS_CONFIG_IN := "${THISDIR}/${PN}/${OS_NAME}.conf"
