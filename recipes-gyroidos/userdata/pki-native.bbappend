DEPENDS += " sbsigntool-native efitools-native"
