TARGET_CFLAGS += "-fpic"
